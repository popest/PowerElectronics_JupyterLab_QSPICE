* Auto-Generated Netlist File
V3 Vlog 0 1
S1 VIN CD high_C 0 MODSW
S3 CD 0 low_D 0 MODSW
S2 VIN AB high_A 0 MODSW
S4 AB 0 low_B 0 MODSW
L1 N02 N01 {Lp} RSER = {I_Res_Lprim}
L2 N14 0 {I_Ls} RSER={I_Res_Lsec}
Lout N03 Vout {Lout}
R1 N07 0 {Cout_ESR}
L5 AB N01 {L_leak}
D7 CD VIN ideal_MOS
D4 0 CD ideal_MOS
D6 AB VIN ideal_MOS
D8 0 AB ideal_MOS
V´I_SENSE N04 VIN 0
¥2 Vlog 0 A B B N06 0 0 ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ D-FLOP TTOL = {I_ttol_factor/fsw_p}
¥1 Vlog 0 C D D N05 0 0 ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ D-FLOP TTOL = {I_ttol_factor/fsw_p}
V6 N13 0 {1-D}
¥3 Vlog 0 N05 N06 N13 RAMP Vlog ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ HMITT VH=2m TTOL={I_ttol_factor/fsw_p}
¥4 Vlog 0 low_B ¥ N09 B ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ AND TTOL={I_ttol_factor/fsw_p}
¥6 Vlog 0 high_A ¥ A N08 ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ AND TTOL={I_ttol_factor/fsw_p}
¥7 Vlog 0 N08 N09 A ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ OR TD={deadtime} TTOL = {I_ttol_factor/fsw_p}
¥8 Vlog 0 low_D ¥ N11 D ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ AND TTOL={I_ttol_factor/fsw_p}
¥9 Vlog 0 high_C ¥ C N10 ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ AND TTOL={I_ttol_factor/fsw_p}
¥10 Vlog 0 N10 N11 C ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ ¥ OR TD={deadtime} TTOL = {I_ttol_factor/fsw_p}
R3 N12 N03 {I_Res_Lout}
V9 N04 0 {Vin}
Rload Vout 0 {max(Vout/(Pmax/Vout),Vout/Iout_max)}
V1 Vout N07 {Vout}
V2 RAMP 0 PULSE 1 0 0 {(I_ttol_factor*10)/(2*fsw_p)} {(1-I_ttol_factor*10)/(2*fsw_p)} 0 {1/(2*fsw_p)}
L9 CD N02 {Lr} RSER = {I_Res_Lr} IC=0
D1 N14 N12 ideal_REC
D3 N15 N12 ideal_REC
L3 0 N15 {I_Ls} RSER={I_Res_Lsec}
K2 L1 L2 L3 1
.param Lp=0.004
.param N=1.07
.param fsw_p=100000.0
.param Lr=2.588333333333333e-05
.param Lout=0.000319953729155214
.param Vout=264.70588235294116
.param D=0.745
.param Vin=400
.param Iout_max=3.4
.param Pmax=675.0
.param L_leak=8e-06
.param Ron_MOS=0.315
.param deadtime=5e-08
.param Rdiff=0.155
.param eff=1
.param Coss=3e-11
.param REC_fwd=0.9
.param Cout_ESR=0.032679738562091505
.param I_Ls={Lp/N^2}
.param TSTEP={(1/(2*fsw_p))/100}
.param TSTOP={5000*1/(2*fsw_p)}
.param TSTART={TSTOP-6/(2*fsw_p)}
.param I_Iout = (Pmax/eff)/Vout
.param I_Res_Lr=1m
.param I_Res_Lprim=1m
.param I_Res_Lsec=1m
.param I_ttol_factor = 0.0001
.param I_Res_Lout = 1m
.model ideal_MOS D(Vfwd=0.7,Ron={Ron_MOS}, Roff=10Meg)
.model MODSW SW(ron={Ron_MOS} roff=100Meg vt=0.5 vh=-0.05 )
.model ideal_REC D(Vfwd={REC_fwd},Ron={Rdiff}, Roff=10Meg)
.options trtol=1
.options maxord=1
.options savepowers
.meas I_Lout_AVG avg I(Lout)
.meas I_Rload_AVG avg I(Rload)
.meas P_Rload_AVG avg P(Rload)
.meas P_Vin_AVG avg P(V9)
.meas V_Vout_AVG avg V(Vout)
.meas I_S2_RMS rms I(S2)
.meas I_Lout_PP PP I(Lout)
.meas V_Vout_PP PP V(Vout)
.meas I_S1_RMS rms I(S1)
.meas I_Lprim_AVG avg I(L1)
.meas I_Lprim_RMS rms I(L1)
.meas I_Lout_RMS rms I(Lout)
.meas I_Lsec1_AVG avg I(L2)
.meas I_Lsec1_RMS rms I(L2)
.meas I_Lsec2_AVG avg I(L3)
.meas I_Lsec2_RMS rms I(L3)
.meas L_res_point FIND I(L9) WHEN V(low_b)=0.5 cross=last
.meas I_Lprim_pp pp I(L1)
.meas I_sense_RMS rms I(I_SENSE)
.meas I_sense_AVG avg I(I_SENSE)
.tran 0 {TSTOP} {TSTART} {TSTEP}
.end
